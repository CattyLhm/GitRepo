# Keil uVision project STM32F103RB.uvprojx, settings and files
target STM32F103RB (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\cmsis_boot;.\STM32F10x_StdPeriph_Driver\inc;.\CoOS\portable;.\CoOS\kernel;.\CoOS\portable\Keil;.\Drive\LED\inc;.\Drive\USART\USART1\inc;.\Drive\ADC\inc;.\Drive\TIM\TIM2\inc;.\Drive\MCPWM\MCPWM1\inc;.\Drive\PWM\TIM3_PWM\inc;.\Drive\CAN\CAN1\inc;.\Drive\USART\USART2\inc;.\Drive\INFRARE_Receive\inc;.\Drive\TIM\TIM3\inc;.\Drive\PWM\TIM4_PWM\inc;.\Drive\BLDC\inc;.\Drive\PID\inc;..\BLDC;.\Drive\KEY\inc;.\Drive\ADC\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c stm32f10x_it.c MCUPeriph_Init.c
  group cmsis
    ./cmsis/: core_cm3.c
  group cmsis_boot
    ./cmsis_boot/: system_stm32f10x.c system_stm32f10x.h
  group startup
    ./cmsis_boot/startup/: startup_stm32f10x_md.s
  group PeriphLib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Port
    ./CoOS/portable/: arch.c
    ./CoOS/portable/Keil/: port.c
  group CoOS
    ./CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c queue.c sem.c serviceReq.c task.c time.c timer.c utility.c
  group USART
    ./Drive/USART/USART1/src/: USART1.c
    ./Drive/USART/USART2/src/: USART2.c
  group BLDC
    ./Drive/BLDC/src/: BLDC.c
  group ADC
    ./Drive/ADC/src/: ADC.c
  group PID
    ./Drive/PID/src/: PID.c
  group LED
    ./Drive/LED/src/: LED.c
  group KEY
    ./Drive/KEY/src/: KEY.c
